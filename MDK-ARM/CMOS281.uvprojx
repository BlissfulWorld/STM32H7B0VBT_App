# Keil uVision project CMOS281.uvprojx, settings and files
target CMOS281 (6160000::V6.16::ARMCLANG)
  device: STM32H7B0VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x240FFFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: CMOS281 +hex
  AfterMake: .\..\mup.exe #H
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7B0xx,USER_VECT_TAB_ADDRESS,VECT_TAB_SRAM
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../User/Inc;../Middlewares/ST/STemWin/inc;../User/Test/inc;../User/UI/STemWin
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x24000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24040000 size 0xc0000
  group User/Config
    ../User/Inc/: config.h
  group User/App
    ../User/App/: app_main.c disk.c sw_info.c isr.c test_board.c wav.c config_file.c json_obj.c resource.c
  group User/Dev
    ../User/Dev/: 24c64.c backlight.c battery.c driver_ina219.c driver_ina219_basic.c driver_ina219_interface.c ip5306.c lcd.c pca9535.c w25qxx.c key.c driver_ina219_shot.c spiflash.c
  group User/HW
    ../User/HW/: hw.c hw_i2c.c hw_pin.c hw_sim_i2c.c
  group User/Test
    ../User/Test/: test.c
  group User/Test/Test_0
    ../User/Test/test_0/: test_0.c test_0_als.c test_0_mic.c test_0_prox.c test_0_ip7.c test_0_ip7plus.c test_0_ip8plus.c
  group User/UI
    ../User/UI/Font/: font.c
    ../User/UI/: ui.c ui_test_0.c ui_menu.c ui_about.c ui_brightness.c ui_config_update.c ui_home.c ui_file.c ui_nonsupport.c
  group Application/MDK-ARM
    ./: startup_stm32h7b0xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c crc.c cryp.c dac.c dma.c hash.c i2c.c iwdg.c octospi.c spi.c tim.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_ospi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/STemWin
    ../Middlewares/ST/STemWin/Lib/: STemWin_CM7_wc16.a
    ../User/UI/STemWin/: GUIConf.c LCDConf_FlexColor.c GUI_X_OS.c
software components: CMSIS:CORE 5.6.0, Data Exchange:JSON:cJSON 1.7.7
